# Keil uVision project Tcp1Wire.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tcp1Wire_debug
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG
  c include: ..\src\app;..\src\board;..\src\onewire;..\src\spl;..\src\spl\inc;..\CMSIS\Core\Include;..\CMSIS\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../src/app/: main.c scheduler.c taskhandler.c
  group board
    ../src/board/: led.c stm32_it.c timer.c usart.c
  group onewire
    ../src/onewire/: onewire.c
  group spl
    ../src/spl/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
  group system
    ./system/: startup_stm32f10x_md.s
    ../CMSIS/Device/Source/: system_stm32f10x.c
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: Tcp1Wire_release
  AfterMake: fromelf --bin "./Objects/Tcp1Wire_release.axf" --output "./Binary/Tcp1Wire_release.bin"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
